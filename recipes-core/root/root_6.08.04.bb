require root.inc

SRC_URI[md5sum] = "982f64c489e52b7e2203918cd0438ceb"
SRC_URI[sha256sum] = "51d8fb902b29223f4c621f7f316e3b9d9fe41cd53403e7274cb5cf47ade9c500"
