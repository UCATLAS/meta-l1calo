require root.inc

SRC_URI[md5sum] = "bef6535a5d0cdf471b550da45a10f605"
SRC_URI[sha256sum] = "aedcfd2257806e425b9f61b483e25ba600eb0ea606e21262eafaa9dc745aa794"
