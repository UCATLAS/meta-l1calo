require ${PN}.inc
PR = "r0"
SRCREV = "a6b99dc0579a53207b7dfe1d16423c2c1daa467e"

