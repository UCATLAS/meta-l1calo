require opc-ua-server-zynq.inc
S = "${WORKDIR}/git"
SRCREV ?= "199bfee8a9853e2042a8436bc5751214b8aeffb0"
