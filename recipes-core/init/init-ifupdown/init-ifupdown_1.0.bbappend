# overwrite interfaces file coming from init-ifupdown
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
