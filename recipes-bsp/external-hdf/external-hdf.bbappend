FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
 
HDF_BASE:gfex-production-p1= "file://"
HDF_PATH:gfex-production-p1= "zfpga_top.xsa"

HDF_BASE:gfex-production-stf= "file://"
HDF_PATH:gfex-production-stf= "zfpga_top.xsa"

HDF_BASE:gfex-prototype4= "file://"
HDF_PATH:gfex-prototype4= "zfpga_top.xsa"